Commit message: Removed  the folder hey

File: urdf/assembly.urdf (robot description, URDF)
Before this commit: robot multipleshapes, 2 links, 1 joints
Links:
- added link torso; collision mesh filename=package://robot_description/meshes/base_link_simple.DAE; visual sphere radius=5
